# Keil uVision project Lab3.uvprojx, settings and files
target Lab3 (6190000::V6.19::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Lab3
  c flags: Optim=2 uC99=1 v6Lang=3 v6LangP=5 wLevel=4
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Code
    ./: Startup.s Lab3Grader.h
    ./src/: Lab3.s
  group Object Code
    ./: pll.o timer3a.o uart.o lab3grader.o
software components: CMSIS:CORE 5.6.0
